# Keil uVision project first.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: first
  c flags: Optim=1 uC99=1
  c include: .;.\freeRTOS\source\include;.\freeRTOS\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c startup_rvmdk.S bit_specific_addressing.h functions.c functions.h
  group freeRTOS
    ./freeRTOS/Source/: list.c queue.c tasks.c timers.c
    ./freeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./freeRTOS/Source/portable/MemMang/: heap_1.c
    ./freeRTOS/Source/include/: FreeRTOSConfig.h
